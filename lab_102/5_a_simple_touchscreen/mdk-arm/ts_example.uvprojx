# Keil uVision project ts_example.uvprojx, settings and files
target ts_example (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.13.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: blinky
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c include: ..\inc;..\..\..\libraries\cmsis\core\inc;..\..\..\libraries\bsp\stm32f7_family\inc;..\..\..\libraries\bsp\stm32f7_discovery\bsp\inc;..\..\..\libraries\bsp\stm32f7_discovery_shu_kit\inc;..\..\..\libraries\stm32f7xx_hal\inc;..\..\..\libraries\stm32f7xx_hal\inc\legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group application
    ../src/: main.c
  group configuration
    ../inc/: stm32f7xx_it.h
    ../src/: stm32f7xx_it.c
  group stm32f7_discovery_bsp_shu
    ../../../libraries/bsp/stm32f7_discovery_shu_kit/src/: adc.c clock.c gpio.c random_numbers.c real_time_clock.c
  group stm32f7_discovery_bsp
    ../../../libraries/bsp/stm32f7_discovery/bsp/src/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
    ../../../libraries/bsp/stm32f7_discovery/components/ft5336/: ft5336.c
software components: CMSIS:CORE 5.4.0, Device:STM32Cube Framework:Classic 1.2.8, Device:STM32Cube HAL:ADC 1.2.8, Device:STM32Cube HAL:Common 1.2.8, Device:STM32Cube HAL:Cortex 1.2.8, Device:STM32Cube HAL:DMA 1.2.8, Device:STM32Cube HAL:DMA2D 1.2.8, Device:STM32Cube HAL:GPIO 1.2.8, Device:STM32Cube HAL:I2C 1.2.8, Device:STM32Cube HAL:LTDC 1.2.8, Device:STM32Cube HAL:PWR 1.2.8, Device:STM32Cube HAL:RCC 1.2.8, Device:STM32Cube HAL:SDRAM 1.2.8, Device:STM32Cube HAL:UART 1.2.8, Device:Startup 1.2.5
