# Keil uVision project IoT data node.uvprojx, settings and files
target IoT data node - debug (6160000::V6.16::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.13.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: IoT Data Node
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: MBEDTLS_MSG_INFO=1,MQTT_TASK=1
  c include: ..\inc;..\..\..\libraries\bsp\stm32f7_discovery_shu_kit\inc;..\..\..\libraries\mqtt\eclipse-paho;..\..\..\libraries\mqtt\eclipse-paho\mdk
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group application
    ../src/: app_main.c run_mqtt.c data_acquisition_thread.c
  group configuration
    ../src/: socket_startup.c main.c entropy_hardware_poll.c
    ../inc/: main.h my_credentials.h rtos_objects.h
  group stm32f7_discovery_bsp_shu
    ../../../libraries/bsp/stm32f7_discovery_shu_kit/src/: clock.c random_numbers.c gpio.c adc.c
  group my_mqtt_client
    ../../../libraries/mqtt/eclipse-paho/: MQTTClient.c
    ../../../libraries/mqtt/eclipse-paho/mdk/: MQTTPlatform.c
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:USART 1.14.0, CMSIS Driver:WiFi:ESP8266 1.4.0, Device:STM32Cube Framework:Classic 1.2.8, Device:STM32Cube HAL:ADC 1.2.8, Device:STM32Cube HAL:Common 1.2.8, Device:STM32Cube HAL:Cortex 1.2.8, Device:STM32Cube HAL:DMA 1.2.8, Device:STM32Cube HAL:GPIO 1.2.8, Device:STM32Cube HAL:PWR 1.2.8, Device:STM32Cube HAL:RCC 1.2.8, Device:STM32Cube HAL:RNG 1.2.8, Device:STM32Cube LL:Common 1.2.8, Device:STM32Cube LL:PWR 1.2.8, Device:STM32Cube LL:RCC 1.2.8, Device:STM32Cube LL:UTILS 1.2.8, Device:Startup 1.2.5, IoT Utility:MQTTPacket 1.1.0, IoT Utility:Socket:WiFi 1.0.0
